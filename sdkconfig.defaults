## sdkconfig.defaults
```kconfig
CONFIG_BOOTLOADER_APP_ROLLBACK_ENABLE=y
CONFIG_APP_ROLLBACK_ENABLE=y
# HTTPUpdate default olarak HTTP/HTTPS'e izin verir; ek ayara gerek yok.
```
